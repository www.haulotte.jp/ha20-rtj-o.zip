Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2020-09-16T13:31:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 16 13:31:13 2020 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{FA48CFAE-067F-4C2C-9FD0-3F270FC8E582}\ifc * Database version: 5507 * Database creation date: Wed Sep 16 13:30:56 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 16 13:30:57 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 16 13:30:57 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: HA 61 RTJ PRO, Construction_Aerial-Equipment_Haulotte_HA61-RTJ-PRO_US:HA 61 RTJ PRO:4036199
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Metal - Haulotte - Grey, Metal - Haulotte - Yellow, Metal - Haulotte - Black, Haulotte, Working_Area, Metal - Haulotte - White, Metal - Haulotte - Red
Type - Autre(Type) - Catégorie: Equipement spécialisé; Machine Weight: 9600 kg/ 21164.38 lb; Nom de la famille: Construction_Aerial-Equipment_Haulotte_HA61-RTJ-PRO_US
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Diesel Articulating Boom; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: HA 61 RTJ PRO; Nom du type: HA 61 RTJ PRO; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/ha20-rtj-pro; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte-usa.com/
Type - Données(Type) - Batteries: 12V - 100 Ah; Drive Speed: 0,5 - 5 km/h/ 0.31-3.11 in; Gradeability: 40% en marche avant 45% en marche arrière; Ground Clearance: 0.35 m/13.78 in; Height - Storage / Transport: 2.93 m/ 115.35 in; Height - Stowed: 2.93 m/ 115.35 in; Horizontal Outreach: 12.2 m/480.31 in; Jib Length: 2.10 m / 82.5 in; Lenght - Storage/Transport: 6.5 m/255.91 in; Length - Stowed: 8.8 m/346.46 in; Lift Capacity: 230 kg/ 507.06 lb; Max Ground Pressure of Wheel on Paved Ground: 12,9 daN/cm²; Oscillating Angle: 4.5°; Platform Height: 18.6 m/ 732.28 in; Platform Rotation: -90° / +90°; Platform Size: 1.83x0.8 m/72.05x31.50 in; Tailswing: 2.83 m / 111.2 in; Tilt: 5°; Tires: 1.025x0.365 m/ 40.35x14.37 in; Turnable Rotation: 360°; Turning Radius - Inside: 2 m/78.74 in; Turning Radius - Outside: 3.75 m/147.64 in; Up and Over Clearance: 8.4 m/330.71 in; Vertical Jib Rotation Angle: -80° / + 60°; Wheelbase: 2.45 m/96.46 in; Width: 2.44 m/96.06 in; Working Height: 20.6 m/ 811.02 in
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: HA 61 RTJ PRO
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_HA61-RTJ-PRO_US: HA 61 RTJ PRO; Famille et type: Construction_Aerial-Equipment_Haulotte_HA61-RTJ-PRO_US: HA 61 RTJ PRO; H: 6.76012 m; ID du type: Construction_Aerial-Equipment_Haulotte_HA61-RTJ-PRO_US: HA 61 RTJ PRO; R: 0 deg; TE: 9.355 m; Type: Construction_Aerial-Equipment_Haulotte_HA61-RTJ-PRO_US: HA 61 RTJ PRO
Construction - Boom Rotation Angle: 73 deg; Maximum Boom Articulation Point Height: 8.4 m; Platform Rotation Angle: 0 deg; Reach Diagram: yes; Telescopic Extend: 9.36 m; Turnable Rotation: 0 deg; Turning Radius: yes; Vertical Jib Rotation Angle: 60 deg; Working Area: yes
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 107.734 m2; Volume: 39.2999 m3
Graphismes - Branding: yes
Phase de construction - Phase de création: Nouvelle construction
